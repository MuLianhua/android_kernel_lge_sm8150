## fs/pathmask/Kconfig
```kconfig
config PATHMASK
    bool "PathMask VFS path masking"
    default y
    help
      Android LKM path masking module.
```
